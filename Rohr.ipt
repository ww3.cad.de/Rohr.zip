# Autodesk Inventor part: Rohr
## iProperties
Created: 2010-03
Part Number: Rohr
Document SubType Name: Modeling
Designer: Thomas
Density: 1 g/cm^3
Author: Thomas
## Feature names
1. Extrusion1
