# Autodesk Inventor assembly: Rohrleitung
## iProperties
Created: 2010-03
Part Number: Rohrleitung
Document SubType Name: Assembly
Designer: Thomas
Author: Thomas
